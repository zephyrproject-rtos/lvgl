## zephyr/Kconfig
```kconfig
if LVGL
osource "$(ZEPHYR_BASE)/modules/lvgl/Kconfig.defaults"
rsource "../Kconfig"
endif
```
